FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://0001-Add-dbus-interface-and-method-to-return-default-gate.patch "
