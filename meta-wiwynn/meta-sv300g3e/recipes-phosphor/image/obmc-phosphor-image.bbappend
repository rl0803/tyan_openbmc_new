OBMC_IMAGE_EXTRA_INSTALL_append_sv300g3e += " entity-manager \
                                              dbus-sensors \
                                              intel-dbus-interfaces \
                                              intel-ipmi-oem \
                                              phosphor-pid-control \
                                            "
