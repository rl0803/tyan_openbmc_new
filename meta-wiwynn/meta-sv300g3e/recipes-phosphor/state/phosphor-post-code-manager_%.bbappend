FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Refer-to-the-postcomplete-change-to-clear-the-post-code-vector.patch \
           "
