RDEPENDS_${PN}-extras_remove += " \
    obmc-ikvm \
    "
