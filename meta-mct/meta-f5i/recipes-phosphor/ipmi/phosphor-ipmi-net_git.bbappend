FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Update-the-remote-ip-addr-to-session-properties.patch \
            "
